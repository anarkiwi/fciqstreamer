options:
  parameters:
    author: Josh Bailey
    category: Custom
    generate_options: no_gui
    id: FCM_IQ_streamer
    output_language: python
    run_options: run
    title: streams I/Q samples
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '128'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '128'
    type: float
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 0.0.0.0
    noblock: 'True'
    port: '1234'
    type: byte
    vlen: '1'
  states: {}
- name: fcdproplus_fcdproplus_0
  id: fcdproplus_fcdproplus
  parameters:
    devicename: ''
    freq: '101300'
    if_gain: '0'
    lnaswitch: '1'
    mixergainswitch: '0'
    ppm: '0'
    unit: '1000'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_float_to_uchar_0, '0', blocks_tcp_server_sink_0, '0']
- [blocks_interleave_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [fcdproplus_fcdproplus_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
