options:
  parameters:
    author: Josh Bailey
    category: Custom
    generate_options: qt_gui
    id: FCM_IQ_streamer
    output_language: python
    title: streams I/Q samples
  states: {}

blocks:
- name: Ifgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    min_len: '45'
    orient: Qt.Vertical
    start: '0'
    step: '1'
    stop: '59'
    value: '10'
    widget: counter
  states: {}
- name: Lna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label0: 'Off'
    label1: 'On'
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: Mixergain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label0: 'Off'
    label1: 'On'
    num_opts: '2'
    option1: '1'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: PPM
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,6,1,1
    label: set PPM
    min_len: '40'
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '100'
    value: '0'
    widget: counter
  states: {}
- name: RxFrequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Set Frequency
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '9999999999'
    value: '101300'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '128'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '128'
    type: float
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ''
    noblock: 'True'
    port: '1234'
    type: byte
    vlen: '1'
  states: {}
- name: fcdproplus_fcdproplus_0
  id: fcdproplus_fcdproplus
  parameters:
    devicename: ''
    freq: RxFrequency
    if_gain: int(Ifgain)
    lnaswitch: Lna
    mixergainswitch: Mixergain
    ppm: int(PPM)
    unit: '1000'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_float_to_uchar_0, '0', blocks_tcp_server_sink_0, '0']
- [blocks_interleave_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [fcdproplus_fcdproplus_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
